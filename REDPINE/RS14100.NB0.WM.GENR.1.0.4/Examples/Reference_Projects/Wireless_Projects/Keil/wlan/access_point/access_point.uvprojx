# Keil uVision project access_point.uvprojx, settings and files
target WiseMCU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: RS14100_1MB Redpine Signals
  pack: Redpine.RS14100_DFP.1.0.5
  cpu: IRAM(0x000000C,0x2FFF4) IROM(0x08012000,0xEE000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: access_point +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=output\access_point.bin Objects\access_point.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -c -s --Output=output\access_point.asm Objects\access_point.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __CC_ARM RSI_SAMPLE_HAL RSI_WLAN_ENABLE RSI_M4_INTERFACE RSI_LITTLE_ENDIAN NO_AES ROM_WIRELESS
  c misc: --reduce_paths
  c include: ..\..\..\..\..\..\Wireless_Library\include;..\..\..\..\..\..\Wireless_Library\hal_WiSeMcu\inc;..\..\..\..\..\..\Wireless_Library\rom;..\..\..\..\..\..\COMMON\chip\inc;..\..\..\..\..\..\COMMON\cmsis;..\..\..\..\..\..\Peripheral_Library\driver\inc;..\..\..\..\..\..\Peripheral_Library\systemlevel\inc;..\..\..\..\..\..\Peripheral_Library\rom_driver\inc;..\..\..\..\..\..\COMMON\board\inc;..\..\..\..\..\..\Peripheral_Library\aes_code\cyassl\ctaocrypt;..\..\..\..\..\..\COMMON\board\inc;..\..\..\..\..\..\Wireless_Library\nwk\applications;..\..\..\..\..\..\Wireless_Library\nwk\applications\mqtt_client\src;..\..\..\..\..\..\Wireless_Library\nwk\applications\mqtt_client\src\MQTTPacket\src;..\..\..\..\..\Wireless_Examples\utilities\certificates;..\..\..\..\..\..\Wireless_Library\nwk\applications\http_server;..\..\..\..\..\..\Wireless_Library\zigbee\profiles\include;..\..\..\..\..\..\Peripheral_Library\cmsis_driver;..\..\..\..\..\..\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include;..\..\..\..\..\..\Peripheral_Library\cmsis_driver\config;..\..\..\..\..\Wireless_Examples\wlan\access_point;..\..\..\..\..\..\rs9116\platforms\garminos;..\..\..\..\..\..\rs9116\platforms\garminos\bsd;..\..\..\..\..\..\rs9116\platforms\garminos\wln_soc_impl;..\..\..\..\..\..\rs9116\platforms\garminos\bsd\sys;..\..\..\..\..\..\modules\grm;..\..\..\..\..\..\modules\grm\legacy;..\..\..\..\..\..\modules\UTL;..\..\..\..\..\..\modules\UTL\assert
  library: MicroLIB
  memory RVCT4: ROM 0x8012000 size 0xee000
  memory RVCT9: RAM 0xc size 0x2fff4
  group start_up
    ../../startup/: startup_RS1xxxx.s
    ../../../../../../COMMON/chip/src/: rsi_system_config.c system_RS1xxxx.c
  group sapis
    ../../../../../../Wireless_Library/driver/: rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_utils.c rsi_wlan.c rsi_timer.c rsi_bt_ble.c rsi_zb.c rsi_zb_utility.c rsi_common.c
    ../../../../../../Wireless_Library/common/: rsi_common_apis.c rsi_device_init_apis.c
    ../../../../../../Wireless_Library/wlan/: rsi_wlan_apis.c
    ../../../../../../Wireless_Library/nwk/socket/: rsi_socket.c
    ../../../../../../Wireless_Library/rom/: rsi_apis_non_rom.c
    ../../../../../../Wireless_Library/nwk/applications/: rsi_dns.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_mdnsd.c rsi_mqtt_client.c rsi_multicast.c rsi_ota_fw_up.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_web_socket.c
    ../../../../../../Wireless_Library/nwk/applications/mqtt_client/src/: MQTT_wrappers.c MQTTClient.c
    ../../../../../../Wireless_Library/nwk/applications/mqtt_client/src/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ../../../../../../Wireless_Library/nwk/applications/http_server/: rsi_http_server.c rsi_json_handlers.c
    ../../../../../../Wireless_Library/bt_ble/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_spp_apis.c
    ../../../../../../Wireless_Library/zigbee/: rsi_zb_apis.c
    ../../../../../../Wireless_Library/zigbee/mac_apis/: rsi_zigb_mac_apis.c
  group example
    ../../../../../Wireless_Examples/wlan/access_point/: rsi_ap_start.c
    ../udp_client/: gethost_implementation.c
    ../../../../../../modules/grm/: GRM_pub.h
    ../../../../../../rs9116/platforms/garminos/bsd/sys/: socket.h
  group hal
    ../../../../../../Wireless_Library/hal_WiSeMcu/src/: rsi_hal_mcu_timer.c rsi_hal_mcu_m4.c rsi_bootup_config.c
  group board
    ../../../../../../COMMON/board/src/: rsi_board.c
  group wisemcu_powersave
    ../../../../../../Peripheral_Library/systemlevel/src/: rsi_pll.c rsi_power_save.c rsi_processor_sensor.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c rsi_wwdt.c rsi_ipmu.c
    ../../../../../../COMMON/chip/src/: rsi_ps_ram_func.c
  group uart_debug_prints
    ../../../../../../Peripheral_Library/cmsis_driver/: USART.c
    ../../../../../../Peripheral_Library/driver/src/: rsi_egpio.c
