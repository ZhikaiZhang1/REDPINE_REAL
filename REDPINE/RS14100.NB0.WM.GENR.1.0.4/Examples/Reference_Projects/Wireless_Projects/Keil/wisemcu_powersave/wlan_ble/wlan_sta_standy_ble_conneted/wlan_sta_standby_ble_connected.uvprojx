# Keil uVision project wlan_sta_standby_ble_connected.uvprojx, settings and files
target WiseMCU (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: RS14100_1MB Redpine Signals
  pack: Redpine.RS14100_DFP.1.0.2
  cpu: IROM(0x08012000,0xEE000) IRAM(0x000000C,0x2FFF4) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wlan_sta_standby_ble_connected +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=output\wlan_sta_standby_ble_connected.bin Objects\wlan_sta_standby_ble_connected.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -c -s --Output=output\wlan_sta_standby_ble_connected.asm Objects\wlan_sta_standby_ble_connected.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __CC_ARM  RSI_SAMPLE_HAL RSI_WLAN_ENABLE  RSI_BLE_ENABLE RSI_M4_INTERFACE  RSI_LITTLE_ENDIAN  NO_AES  FPGA_VALIDATION  ROM_WIRELESS PS_ROMDRIVER_PRESENT ENABLE_DEBUG_MODULE ALARM_CONFIG
  c misc: --reduce_paths
  c include: ..\..\..\..\..\..\..\Wireless_Library\include;..\..\..\..\..\..\..\Wireless_Library\hal_WiSeMcu\inc;..\..\..\..\..\..\..\Wireless_Library\rom;..\..\..\..\..\..\..\COMMON\chip\inc;..\..\..\..\..\..\..\COMMON\cmsis;..\..\..\..\..\..\..\Peripheral_Library\driver\inc;..\..\..\..\..\..\..\Peripheral_Library\systemlevel\inc;..\..\..\..\..\..\..\Peripheral_Library\rom_driver\inc;..\..\..\..\..\..\..\COMMON\board\inc;..\..\..\..\..\..\..\Peripheral_Library\aes_code\cyassl\ctaocrypt;..\..\..\..\..\..\..\Peripheral_Library\cmsis_driver\config;..\..\..\..\..\..\..\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include;..\..\..\..\..\..\..\Peripheral_Library\cmsis_driver;..\..\..\..\..\..\Wireless_Examples\utilities\certificates;..\..\..\..\..\..\..\Wireless_Library\nwk\applications;..\..\..\..\..\..\..\Wireless_Library\nwk\applications\mqtt_client\src;..\..\..\..\..\..\..\Wireless_Library\nwk\applications\mqtt_client\src\MQTTPacket\src;..\..\..\..\..\..\..\Wireless_Library\nwk\applications\http_server;..\..\..\..\..\..\Wireless_Examples\wisemcu_powersave\wlan_ble\stdby_ble_co
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x800c size 0x10000
  group start_up
    ../../../../../../../COMMON/chip/src/: rsi_ps_ram_func.c system_RS1xxxx.c rsi_system_config.c
    ../../../startup/: startup_RS1xxxx.s
  group sapis
    ../../../../../../../Wireless_Library/driver/: rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_utils.c rsi_wlan.c rsi_bt_ble.c rsi_timer.c
    ../../../../../../../Wireless_Library/common/: rsi_common_apis.c rsi_device_init_apis.c
    ../../../../../../../Wireless_Library/wlan/: rsi_wlan_apis.c
    ../../../../../../../Wireless_Library/nwk/socket/: rsi_socket.c
    ../../../../../../../Wireless_Library/rom/: rsi_apis_non_rom.c
    ../../../../../../../Wireless_Library/bt_ble/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_ble_l2cap_conn.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_spp_apis.c
    ../../../../../../../Wireless_Library/nwk/applications/: rsi_dns.c rsi_mqtt_client.c
    ../../../../../../../Wireless_Library/nwk/applications/mqtt_client/src/: MQTT_wrappers.c MQTTClient.c
    ../../../../../../../Wireless_Library/nwk/applications/mqtt_client/src/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group example
    ../../../../../../Wireless_Examples/wisemcu_powersave/wlan_ble/stdby_ble_co/: main.c rsi_ble_app.c rsi_wlan_app.c
  group hal
    ../../../../../../../Wireless_Library/hal_WiSeMcu/src/: rsi_hal_mcu_timer.c rsi_hal_mcu_m4.c rsi_bootup_config.c
  group board
    ../../../../../../../COMMON/board/src/: rsi_board.c
  group wisemcu_powersave
    ../../../../../../../Peripheral_Library/systemlevel/src/: rsi_pll.c rsi_power_save.c rsi_processor_sensor.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c rsi_wwdt.c rsi_rtc.c
  group uart_debug_prints
    ../../../../../../../Peripheral_Library/driver/src/: rsi_egpio.c
    ../../../../../../../Peripheral_Library/cmsis_driver/: USART.c
  group M4_files
    ../../../../../../../Peripheral_Library/systemlevel/src/: rsi_ipmu.c
    ../../../../../../../Wireless_Library/common/: rsi_wisemcu_hardware_setup.c
