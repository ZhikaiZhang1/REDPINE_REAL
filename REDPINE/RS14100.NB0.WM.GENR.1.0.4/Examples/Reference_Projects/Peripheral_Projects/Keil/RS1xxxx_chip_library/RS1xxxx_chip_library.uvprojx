# Keil uVision project RS1xxxx_chip_library.uvprojx, settings and files
target Redpine MCU library (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RS1xxxx_chip_library (library)
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM DEBUG_UART
  c include: ..\..\..\board\inc;..\..\..\common\chip\inc;..\..\..\common\cmsis;..\..\..\library\cmsis_driver;..\..\..\library\cmsis_driver\CMSIS\Driver\Include;..\..\..\library\cmsis_driver\config;..\..\..\library\driver\inc;..\..\..\library\rom_driver\inc;..\..\..\library\systemlevel\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  group lib
    ../../../library/driver/src/: rsi_cci.c rsi_comparator.c rsi_crc.c rsi_ct.c rsi_efuse.c rsi_egpio.c rsi_ethernet.c rsi_fim.c rsi_fim_filterScalar.c rsi_ir.c rsi_pwm.c rsi_qei.c rsi_qspi.c rsi_rng.c rsi_rpdma.c rsi_sio.c rsi_timers.c rsi_udma.c
    ../../../common/chip/src/: rsi_ps_ram_func.c
  group power_clk
    ../../../library/systemlevel/src/: rsi_calendar.c rsi_ipmu.c rsi_pll.c rsi_power_save.c rsi_processor_sensor.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c rsi_wwdt.c
  group Board
    ../../../board/src/: rsi_board.c
  group cmsis driver
    ../../../library/cmsis_driver/: CAN.c EMAC.c I2C.c MCI.c PHY_LAN8742A.c SAI.c SPI.c USART.c USB.c USBD.c USBH.c UDMA.c
