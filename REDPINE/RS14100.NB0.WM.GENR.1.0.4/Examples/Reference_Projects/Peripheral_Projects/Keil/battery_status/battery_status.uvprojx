# Keil uVision project battery_status.uvprojx, settings and files
target Redpine MCU library (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: RS14100_1MB Redpine Signals
  pack: Redpine.RS14100_DFP.1.0.2
  cpu: IRAM(0x000000C,0x2FFF4) IROM(0x08012000,0xEE000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: battery_status
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -c -s --output=output\battery_status.asm Objects\battery_status.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=output\battery_status.bin Objects\battery_status.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM
  c include: ..\..\..\..\..\COMMON\board\inc;..\..\..\..\..\COMMON\chip\inc;..\..\..\..\..\COMMON\cmsis;..\..\..\..\..\Peripheral_Library\cmsis_driver;..\..\..\..\..\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include;..\..\..\..\..\Peripheral_Library\cmsis_driver\config;..\..\..\..\..\Peripheral_Library\driver\inc;..\..\..\..\..\Peripheral_Library\rom_driver\inc;..\..\..\..\..\Peripheral_Library\systemlevel\inc;..\..\..\..\..\Peripheral_Library\systemlevel\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8012000 size 0xee000
  memory RVCT9: RAM 0xc size 0x2fff4
  group startup
    ../../../../../COMMON/chip/src/: system_RS1xxxx.c rsi_system_config.c
    ../Keil_startup/: startup_RS1xxxx.s
  group example
    ../../../../Peripheral_Examples/battery_status/: readm.txt rsi_bod_vbattsoftintr_example.c
  group lib
    ../../../../../Peripheral_Library/driver/src/: rsi_cci.c rsi_comparator.c rsi_crc.c rsi_ct.c rsi_efuse.c rsi_egpio.c rsi_ethernet.c rsi_fim.c rsi_fim_filterScalar.c rsi_ir.c rsi_pwm.c rsi_qei.c rsi_qspi.c rsi_rng.c rsi_gpdma.c rsi_sio.c rsi_timers.c rsi_udma.c
    ../../../../../COMMON/chip/src/: rsi_ps_ram_func.c
  group power_clk
    ../../../../../Peripheral_Library/systemlevel/src/: rsi_ipmu.c rsi_pll.c rsi_bod.c rsi_power_save.c rsi_processor_sensor.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c rsi_wwdt.c rsi_rtc.c
  group Board
    ../../../../../COMMON/board/src/: rsi_board.c
  group cmsis driver
    ../../../../../Peripheral_Library/cmsis_driver/: CAN.c I2C.c MCI.c SAI.c SPI.c USART.c UDMA.c
