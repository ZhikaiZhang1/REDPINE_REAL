# Keil uVision project wurx_demo_example.uvprojx, settings and files
target Redpine MCU library (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: RS14100_1MB Redpine Signals
  pack: Redpine.RS14100_DFP.1.0.2
  cpu: IRAM(0x000000C,0x2FFF4) IROM(0x08012000,0xEE000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wurx_demo_example
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe -c -s --output=output\wurx_demo_example.asm Objects\wurx_demo_example.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=output\wurx_demo_example.bin Objects\wurx_demo_example.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM ROMDRIVER_PRESENT DEBUG_UART
  c include: ..\..\..\..\..\COMMON\board\inc;..\..\..\..\..\COMMON\chip\inc;..\..\..\..\..\COMMON\cmsis;..\..\..\..\..\Peripheral_Library\cmsis_driver;..\..\..\..\..\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include;..\..\..\..\..\Peripheral_Library\cmsis_driver\config;..\..\..\..\..\Peripheral_Library\driver\inc;..\..\..\..\..\Peripheral_Library\rom_driver\inc;..\..\..\..\..\Peripheral_Library\systemlevel\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8012000 size 0x4000
  memory RVCT9: RAM 0xc00 size 0x1500
  group startup
    ../../../../../COMMON/chip/src/: system_RS1xxxx.c rsi_system_config.c
    ../Keil_startup/: startup_RS1xxxx.s
  group example
    ../../../../Peripheral_Examples/wurx_demo_example/: wurx_demo_example.c readme.txt wurx_hardware_setup.c
  group lib
    ../../../../../Peripheral_Library/driver/src/: rsi_egpio.c rsi_wurx.c
    ../../../../../COMMON/chip/src/: rsi_ps_ram_func.c
  group power_clk
    ../../../../../Peripheral_Library/systemlevel/src/: rsi_ipmu.c rsi_pll.c rsi_power_save.c rsi_time_period.c rsi_ulpss_clk.c rsi_temp_sensor.c
  group Board
    ../../../../../COMMON/board/src/: rsi_board.c
  group cmsis driver
    ../../../../../Peripheral_Library/cmsis_driver/: USART.c
