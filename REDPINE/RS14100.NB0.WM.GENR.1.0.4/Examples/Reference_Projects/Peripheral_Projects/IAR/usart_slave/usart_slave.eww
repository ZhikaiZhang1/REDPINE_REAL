<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\usart_slave.ewp</path>
    </project>
    <batchBuild />
</workspace>
