# IAR project crc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RS14100_1MB Redpine RS14100_1MB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __ICCARM__
  ICCARM.IExtraOptions: --diag_suppress Pa093,Pe301,Pa082,Pa084,Pe177,Pe549
  ICCARM.CCIncludePath2: ..\..\..\..\..\Common\board\inc; ..\..\..\..\..\Common\chip\inc; ..\..\..\..\..\Common\cmsis; ..\..\..\..\..\Peripheral_Library\cmsis_driver; ..\..\..\..\..\Peripheral_Library\cmsis_driver\CMSIS\Driver\Include; ..\..\..\..\..\Peripheral_Library\cmsis_driver\config; ..\..\..\..\..\Peripheral_Library\driver\inc; ..\..\..\..\..\Peripheral_Library\rom_driver\inc; ..\..\..\..\..\Peripheral_Library\systemlevel\inc; ..\..\..\..\..\Peripheral_Examples\crc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: crc.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    ../../../../../Common/board/src/: rsi_board.c
  group cmsis_driver
    ../../../../../Peripheral_Library/cmsis_driver/: CAN.c EMAC.c I2C.c MCI.c PHY_LAN8742A.c SAI.c SPI.c UDMA.c USART.c USB.c USBD.c USBH.c
  group example
    ../../../../Peripheral_Examples/crc/: M4_CRC_UDMA.c readme.txt sw_crc.c
  group lib
    ../../../../../Peripheral_Library/driver/src/: rsi_adc.c rsi_cci.c rsi_comparator.c rsi_crc.c rsi_ct.c rsi_cts.c rsi_dac.c rsi_efuse.c rsi_egpio.c rsi_ethernet.c rsi_fim.c rsi_fim_filterScalar.c rsi_gpdma.c rsi_gspi.c rsi_ir.c rsi_opamp.c rsi_pwm.c rsi_qei.c rsi_qspi.c rsi_rng.c rsi_sio.c rsi_timers.c rsi_udma.c rsi_wurx.c
    ../../../../../Common/chip/src/: rsi_ps_ram_func.c
  group power_clk
    ../../../../../Peripheral_Library/systemlevel/src/: rsi_bod.c rsi_ipmu.c rsi_pll.c rsi_power_save.c rsi_processor_sensor.c rsi_rtc.c rsi_temp_sensor.c rsi_time_period.c rsi_ulpss_clk.c rsi_wwdt.c
  group startup
    ../../../../../Common/chip/src/: rsi_system_config.c system_RS1xxxx.c
    ../IAR_startup/: startup_iar.s
